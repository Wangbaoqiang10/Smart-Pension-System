# Keil uVision project moban.uvprojx, settings and files
target moban (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: moban +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\libraries\inc;.\libraries\src;.\startup;.\user;.\system\delay;.\system\sys;.\system\usart1;.\system\wdg;.\app;.\app\led;.\app\pit;.\app\spi;.\app\NRF24L01;..\nRF24L01_Slave
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c includes.c
    ./: led.c led.h
  group system
    ./system/delay/: delay.c
    ./system/sys/: sys.c
    ./system/usart1/: usart1.c
    ./system/wdg/: wdg.c
  group app
    ./app/pit/: pit.c
    ./app/spi/: spi.c
    ./app/NRF24L01/: 24l01.c
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group libraries
    ./libraries/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_wwdg.c misc.c stm32f10x_dbgmcu.c stm32f10x_tim.c stm32f10x_spi.c
software components: CMSIS:CORE 5.4.0
